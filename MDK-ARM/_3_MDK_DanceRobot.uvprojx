# Keil uVision project _3_MDK_DanceRobot.uvprojx, settings and files
target _3_MDK_DanceRobot (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: _3_MDK_DanceRobot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE,MPU6050,EMPL
  c include: ../Core/Inc;../DMP_MPU6050;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../J-Link_RTT;../Single_action;../Task;../LX-16A;../IMU;../FIFO;../I2S_beat;../Leg_action;../Body_action;../Location_deal;../Optical_flow;../WS2812;../Servo_pwm;../Drivers/CMSIS/DSP/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c i2c.c i2s.c iwdg.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group J-Link_RTT
    ../J-Link_RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group Single_action
    ../Single_action/: Single_action.c Single_action.h Single_action_data.c
  group Task
    ../Task/: Task.c Task.h
  group LX-16A
    ../LX-16A/: LX-16A.c LX-16A.h
  group IMU
    ../IMU/: IMU.c IMU.h
  group FIFO
    ../FIFO/: FIFO.c FIFO.h
  group I2S_beat
    ../I2S_beat/: I2S_beat.c I2S_beat.h Beat_data.c
  group Leg_action
    ../Leg_action/: Leg_action_data.c Leg_action.c Leg_action.h Gait.c
  group Location_deal
    ../Location_deal/: Location_deal.c Location_deal.h
  group Body_action
    ../Body_action/: Body_action_data.c Body_action.h Body_action.c
  group Optical_flow
    ../Optical_flow/: Optical_flow.c Optical_flow.h
  group WS2812
    ../WS2812/: ws2812.c ws2812.h
  group Serve_pwm
    ../Servo_pwm/: Servo_pwm.c Servo_pwm.h
software components: CMSIS:CORE 5.5.0
